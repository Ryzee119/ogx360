# EAGLE design ogx360 (EAGLE 9.2.2)

## Parts
C1  100n  C-EUC0402K  [C0402K]
C2  18p  C-EUC0402K  [C0402K]
C3  18p  C-EUC0402K  [C0402K]
C4  100n  C-EUC0402K  [C0402K]
C5  100n  C-EUC0402K  [C0402K]
C6  10u  CPOL-EU153CLV-0405  [153CLV-0405]
C7  100n  C-EUC0402K  [C0402K]
C8  100n  C-EUC0402K  [C0402K]
D1  SOD523  DIODE-SOD523  [SOD523]
D2  SOD523  DIODE-SOD523  [SOD523]
D3  SOD523  DIODE-SOD523  [SOD523]
F1  6V/0.5A  PPTC_HALF-AMP  [1206]
J1  USB_A_SMT_FEMALE_NS  [USB-A-S-NOSILK-FEMALE]
PWR  LEDCHIP-LED0805  [CHIP-LED0805]
Q1  12MHz  CRYSTALSMD-5X3.2-4PAD  [CRYSTAL-SMD-5X3.2-4PAD]
R1  33R  R-EU_R0402  [R0402]
R2  33R  R-EU_R0402  [R0402]
R3  1k  R-EU_R0402  [R0402]
R4  1k  R-EU_R0402  [R0402]
R5  1k  R-EU_R0402  [R0402]
R6  1k  R-EU_R0402  [R0402]
R7  1k  R-EU_R0402  [R0402]
RESET  TL3305AF160QG  [TL3305AF160QG]
U1  MAX3421  MAX3421ESMD  [TQFP32-5MM]
U2  74HC4050  HEX_CONVERTER  [SO16]
U3  MIC5219 3.3V  V_REG_MIC52193.3V  [SOT23-5]
U4  ARDUINO_LEONARDO_MICRO  [ARDUINO_LEONARDO_MICRO]
U5  ARDUINO_LEONARDO_MICRO  [ARDUINO_LEONARDO_MICRO]
U6  ARDUINO_LEONARDO_MICRO  [ARDUINO_LEONARDO_MICRO]
U7  ARDUINO_LEONARDO_MICRO  [ARDUINO_LEONARDO_MICRO]

## Nets
+3V3: C4.1 C5.1 C6.+ C7.1 C8.1 R5.2 U1.2(VL) U1.23(VCC) U2.1(VCC) U3.5(OUT)
+5V: D1.A D2.A D3.A F1.2 R3.2 R4.2 U3.1(IN) U3.3(EN) U4.P$1(RAW)
D_N: R2.1 U1.20(D-)
D_P: R1.1 U1.21(D+)
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.- C7.2 C8.2 J1.GND J1.SHLD1(SHIELD) J1.SHLD2(SHIELD) PWR.C RESET.P$3 RESET.P$4 U1.3(GND) U1.19(GND) U2.8(GND) U3.2(GND) U4.P$2(GND) U4.P$6(D20/A2) U4.P$7(D19/A1) U4.P$21(GND) U4.P$22(GND) U5.P$2(GND) U5.P$7(D19/A1) U5.P$21(GND) U5.P$22(GND) U6.P$2(GND) U6.P$6(D20/A2) U6.P$21(GND) U6.P$22(GND) U7.P$2(GND) U7.P$21(GND) U7.P$22(GND)
I2C_SCL: R6.1 U4.P$19(D3/SCL) U5.P$19(D3/SCL) U6.P$19(D3/SCL) U7.P$19(D3/SCL)
I2C_SDA: R7.1 U4.P$20(D2/SDA) U5.P$20(D2/SDA) U6.P$20(D2/SDA) U7.P$20(D2/SDA)
MISO: U1.15(MISO) U4.P$10(D14/MISO)
MOSI: U2.3(1A) U4.P$11(D16/MOSI)
MOSI_IN: U1.16(MOSI) U2.2(1Y)
N$1: D1.C U5.P$1(RAW)
N$2: R3.1 R6.2
N$3: D2.C U6.P$1(RAW)
N$4: D3.C U7.P$1(RAW)
N$5: J1.D+ R1.2
N$6: R4.1 R7.2
N$8: J1.D- R2.2
N$9: C2.1 Q1.1 U1.25(X0)
N$10: C3.1 Q1.3 U1.24(X1)
N$13: U4.P$24(D0/TX) U5.P$23(D1/RX) U6.P$23(D1/RX) U7.P$23(D1/RX)
N$14: PWR.A R5.1
N$138: F1.1 J1.VBUS
RESET: RESET.P$1 RESET.P$2 U4.P$3(RST) U5.P$3(RST) U6.P$3(RST) U7.P$3(RST)
SCK: U2.7(3A) U4.P$9(D15/SCLK)
SCK_IN: U1.13(SCK) U2.6(3Y)
USB_RESET: U2.9(4A) U4.P$13(A9/D9)
USB_RESET_IN: U1.12(RES) U2.10(4Y)
USB_SS: U2.5(2A) U4.P$12(D10/A10)
USB_SS_IN: U1.14(SS) U2.4(2Y)
VBCOMP: C1.1 U1.22(VBCOMP)
Unconnected: U1.1(GPIN7) U1.4(GOUT0) U1.5(GOUT1) U1.6(GOUT2) U1.7(GOUT3) U1.8(GOUT4) U1.9(GOUT5) U1.10(GOUT6) U1.11(GOUT7) U1.17(GPX) U1.18(INT) U1.26(GPIN0) U1.27(GPIN1) U1.28(GPIN2) U1.29(GPIN3) U1.30(GPIN4) U1.31(GPIN5) U1.32(GPIN6) U2.11(5A) U2.12(5Y) U2.14(6A) U2.15(6Y) U3.4(BP) U4.P$4(VCC) U4.P$5(D21/A3) U4.P$8(D18/A0) U4.P$14(A8/D8) U4.P$15(D7) U4.P$16(A7/D6) U4.P$17(D5) U4.P$18(A6/D4) U4.P$23(D1/RX) U5.P$4(VCC) U5.P$5(D21/A3) U5.P$6(D20/A2) U5.P$8(D18/A0) U5.P$9(D15/SCLK) U5.P$10(D14/MISO) U5.P$11(D16/MOSI) U5.P$12(D10/A10) U5.P$13(A9/D9) U5.P$14(A8/D8) U5.P$15(D7) U5.P$16(A7/D6) U5.P$17(D5) U5.P$18(A6/D4) U5.P$24(D0/TX) U6.P$4(VCC) U6.P$5(D21/A3) U6.P$7(D19/A1) U6.P$8(D18/A0) U6.P$9(D15/SCLK) U6.P$10(D14/MISO) U6.P$11(D16/MOSI) U6.P$12(D10/A10) U6.P$13(A9/D9) U6.P$14(A8/D8) U6.P$15(D7) U6.P$16(A7/D6) U6.P$17(D5) U6.P$18(A6/D4) U6.P$24(D0/TX) U7.P$4(VCC) U7.P$5(D21/A3) U7.P$6(D20/A2) U7.P$7(D19/A1) U7.P$8(D18/A0) U7.P$9(D15/SCLK) U7.P$10(D14/MISO) U7.P$11(D16/MOSI) U7.P$12(D10/A10) U7.P$13(A9/D9) U7.P$14(A8/D8) U7.P$15(D7) U7.P$16(A7/D6) U7.P$17(D5) U7.P$18(A6/D4) U7.P$24(D0/TX)

## Buses
SPI_BUS_5V:MISO,MOSI,SCK,USB_RESET,USB_SS
SPI_BUS_3.3V:MISO,MOSI_IN,SCK_IN,USB_RESET_IN,USB_SS_IN
I2C_SCL,I2C_SDA

## Notes on the sheet
- 5V to 3.3V
- USB HOST
  CONTROLLER
- USB PERIPHERAL
  CONTROLLER 1
- USB PERIPHERAL
  CONTROLLER 2
- USB PERIPHERAL
  CONTROLLER 3
- (OPTIONAL) | (OPTIONAL)
- CONTROLLER SERIAL BUS (NOT USED)
- CONTROLLER I2C BUS
- 500mA
- USB PERIPHERAL
  CONTROLLER 4
- (OPTIONAL)
- SPI LEVEL SHIFTER 5V/3.3V
- https://github.com/Ryzee119/ogx360
- Xbox 360 Wireless Adaptor for the Original Xbox
- BY RYZEE119
- ogx360
- October 2018
- A combination of D19/D20 inputs are
  used to determine the Player ID
  D19/D20 have the internal pull-up resistors
  enabled, so if left floating these are '1'.
  D19/D20
  00=Player 1
  01=Player 2
  10=Player 3
  11=Player 4
- 0

## Library data of the parts
C1-C5 C7 C8 = rcl:C-EU: CAPACITOR, European symbol; SPICEPREFIX: C
C6 = rcl:CPOL-EU: POLARIZED CAPACITOR, European symbol; SPICEPREFIX: C
D1-D3 = diode:DIODE-: DIODE
F1 = SparkFun-Fuses:PPTC: Resettable Fuse PPTC; PROD_ID: RES-08585
J1 = SparkFun-Connectors:USB_A: USB-A Connector Male and female variants, as well as PTH and SMT variants SparkFun Products: SparkFun XBee Explorer Dongle PTH Male SparkFun MicroView-USB Programmer SMT Male SparkFun USB Type A Female Breakout SMT Female; PROD_ID: CONN-09520; SF_ID: PRT-09011
PWR = led:LED: LED
Q1 = SparkFun-Clocks:CRYSTAL: Crystals (Generic)
R1-R7 = rcl:R-EU_: RESISTOR, European symbol; SPICEPREFIX: R
RESET = my-library:TL3305AF160QG
U1 = SparkFun-IC-Comms:MAX3421E: MAX3421EEHJ USB Peripheral / Host Controller. SPI, 32TQFP SparkFun Products SparkFun USB Host Shield (DEV-09947); PROD_ID: IC-09517
U2 = SparkFun-IC-Comms:HEX_CONVERTER: 74HC4050 Hex Buffer 74HC4050 Hex Buffer Level Shifter SMD SO016 SparkFun Products CAN-BUS Shield (DEV-13262) SparkFun MP3 Player Shield (DEV-12660) SparkFun microSD Shield (DEV-12761) SparkFun USB Host Shield (DEV-09947); PROD_ID: IC-09604
U3 = SparkFun-IC-Power:V_REG_MIC5219: V_REG MIC5219 Standard 3.3V and 5V 500mA LDO voltage regulator in SOT-23 layout. Micrel part MIC5219. BP (by-pass) pin is used to lower output noise with 470pF cap, may be left open.; PROD_ID: VREG-09872
U4-U7 = my-library:ARDUINO_LEONARDO_MICRO

## Board

Size 97.13 x 36.5 mm. Coordinates in mm from the lower left corner, seen from the top.
Outline: 0,0 97.13,0 97.13,36.5 0,36.5 0,0
Copper layers (1*16): Top 0.035mm / dielectric 1.5mm / Bottom 0.035mm
Design rules "Elecrow_2-layer_eagle_rule": minimum track width 6mil, minimum drill 12mil, track to track 6mil, track to pad 6mil, pad to pad 6mil, via to via 6mil, smd to smd 0mil, copper to edge 10mil, drill to drill 10mil, minimum pad ring 10mil, minimum via ring 6mil, stop-mask expansion 2mil, vias tented up to drill 100mil, thermal gap 10mil

### Footprints (pad centres in the part's own frame; a part is rotated, then mirrored left to right if it is on the bottom)
C0402K = smd 0.925 x 0.74: 1 -0.6,0; 2 0.6,0
153CLV-0405 = smd 2.6 x 1.6: + 1.8,0; - -1.8,0
SOD523 = smd 0.7 x 0.5: A 0.7,0; C -0.6,0
1206 = smd 1.6 x 1.8: 1 -1.4,0; 2 1.4,0
USB-A-S-NOSILK-FEMALE = smd 3 x 0.9: D+ 6.752,-1; D- 6.752,1; GND 6.752,-3.5; VBUS 6.752,3.5 | drill 2.311: SHLD1 2.54,-6.566; SHLD2 2.54,6.566
CHIP-LED0805 = smd 1.2 x 1.2: A 0,-1.05; C 0,1.05
CRYSTAL-SMD-5X3.2-4PAD = smd 1.9 x 1.1: 1 -1.85,-1.15; 2 1.85,-1.15; 3 1.85,1.15; 4 -1.85,1.15
R0402 = smd 0.6 x 0.7: 1 -0.5,0; 2 0.5,0
TL3305AF160QG = smd 1.778 x 1.778: P$1 -3.6,-1.7; P$2 3.6,-1.7; P$3 -3.6,1.7 | smd 1.778 x 1.779: P$4 3.6,1.7
TQFP32-5MM = smd 1.143 x 0.254: 1 -3.5,1.75; 2 -3.5,1.25; 3 -3.5,0.75; 4 -3.5,0.25; 5 -3.5,-0.25; 6 -3.5,-0.75; 7 -3.5,-1.25; 8 -3.5,-1.75; 17 3.5,-1.75; 18 3.5,-1.25; 19 3.5,-0.75; 20 3.5,-0.25; 21 3.5,0.25; 22 3.5,0.75; 23 3.5,1.25; 24 3.5,1.75 | smd 0.254 x 1.143: 9 -1.75,-3.5; 10 -1.25,-3.5; 11 -0.75,-3.5; 12 -0.25,-3.5; 13 0.25,-3.5; 14 0.75,-3.5; 15 1.25,-3.5; 16 1.75,-3.5; 25 1.75,3.5; 26 1.25,3.5; 27 0.75,3.5; 28 0.25,3.5; 29 -0.25,3.5; 30 -0.75,3.5; 31 -1.25,3.5; 32 -1.75,3.5
SO16 = smd 0.6 x 1.2: 1 -4.445,-2.8; 2 -3.175,-2.8; 3 -1.905,-2.8; 4 -0.635,-2.8; 5 0.635,-2.8; 6 1.905,-2.8; 7 3.175,-2.8; 8 4.445,-2.8; 9 4.445,2.8; 10 3.175,2.8; 11 1.905,2.8; 12 0.635,2.8; 13 -0.635,2.8; 14 -1.905,2.8; 15 -3.175,2.8; 16 -4.445,2.8
SOT23-5 = smd 0.55 x 1.2: 1 -0.95,-1.3; 2 0,-1.3; 3 0.95,-1.3; 4 0.95,1.3; 5 -0.95,1.3
ARDUINO_LEONARDO_MICRO = drill 1 pad 1.88: P$1 16.51,29.21; P$2 16.51,26.67; P$3 16.51,24.13; P$4 16.51,21.59; P$5 16.51,19.05; P$6 16.51,16.51; P$7 16.51,13.97; P$8 16.51,11.43; P$9 16.51,8.89; P$10 16.51,6.35; P$11 16.51,3.81; P$12 16.51,1.27; P$13 1.27,1.27; P$14 1.27,3.81; P$15 1.27,6.35; P$16 1.27,8.89; P$17 1.27,11.43; P$18 1.27,13.97; P$19 1.27,16.51; P$20 1.27,19.05; P$21 1.27,21.59; P$22 1.27,24.13; P$23 1.27,26.67; P$24 1.27,29.21

### Placement (x,y rotation side)
C1  11.43,27.94 0 top
C2  3.17,18.41 180 top
C3  3.17,26.04 0 top
C4  9.53,17.14 0 top
C5  7.94,27.94 180 top
C6  19.21,12.06 270 top
C7  18.1,18.41 270 top
C8  16.83,18.41 270 top
D1  50.48,30.48 180 top
D2  68.58,30.48 180 top
D3  87.31,30.48 180 top
F1  3.17,13.97 90 top
J1  8.89,4.76 90 top
PWR  3.17,33.66 0 top
Q1  3.17,22.23 90 top
R1  10.48,14.92 270 top
R2  8.57,14.92 270 top
R3  33.18,16.51 180 top
R4  33.66,21.91 180 top
R5  3.17,30.48 270 top
R6  35.4,16.51 180 top
R7  35.88,21.91 180 top
RESET  10.48,31.75 0 top
U1  10.16,22.23 90 top
U2  31.11,8.89 270 top
U3  14.61,17.78 0 top
U4  22.22,1.91 0 top
U5  40.96,1.91 0 top
U6  59.69,1.91 0 top
U7  78.42,1.91 0 top

### Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via)
+3V3  (via drill 0.35)
  Top 0.254: v25.4,12.06 26.13,12.06 26.74,12.67 27.65,12.67 U2.1
  Bottom 0.254: v19.37,7.94 20.64,7.94 22.28,9.58 24.82,9.58 25.4,10.16 v25.4,12.06
  pour Top: -4.45,-1.27 -4.45,39.37 20.95,39.37 20.95,-1.27
+5V  (via drill 0.35)
  Top 0.305: v16.51,16.19 15.84,16.19 U3.3 | 44.77,34.29 45.4,34.29 63.82,34.29 | 63.82,34.29 63.82,31.11 64.45,30.48 D2.A | 44.77,34.29 44.77,31.11 45.4,30.48 D1.A | D3.A 86.51,30.59 85.41,30.59 85.41,33.02 84.14,34.29 63.82,34.29 | R3.2 32.07,16.51 v31.43,17.14 | v32.86,23.34 33.15,23.04 R4.2 | v35.24,34.29 38.42,34.29 | 38.42,34.29 44.77,34.29 | U4.P$1 38.42,31.43 38.42,34.29
  Top 0.406: F1.2 3.3,15.24 | U3.3 15.56,17.46 15.24,17.78 13.97,17.78 13.66,17.46 U3.1 13.66,15.56 13.49,15.4 13.34,15.24 v12.38,15.24
  Top 0.508: 3.3,15.24 v5.71,15.24
  Bottom 0.305: v16.51,16.19 21.27,16.19 22.22,17.14 24.45,17.14 24.77,17.14 30.64,23.02 30.96,23.34 31.43,23.34 | 31.43,23.34 v32.86,23.34 32.86,31.91 v35.24,34.29 | v31.43,17.14 31.43,23.34
  Bottom 0.508: v5.71,15.24 v12.38,15.24
D_N
  Top 0.254: U1.20 10.41,24.52 10.48,24.45 12.38,24.45 12.38,23.81 10.48,23.81 10.48,23.18 12.38,23.18 12.38,22.54 10.48,22.54 10.48,21.91 12.38,21.91 12.38,21.27 11.75,21.27 11.75,20.8 12.38,20.8 12.38,20.32 8.57,20.32 7.57,19.31 7.57,16.51 8.57,15.51 R2.1
D_P
  Top 0.254: R1.1 9.54,15.42 9.2,15.08 9.2,14.01 8.62,13.42 8.62,9.9 8.3,9.58 7.17,9.58 6.99,9.76 6.99,19.37 7.3,19.68 9.91,22.29 U1.21
GND  (via drill 0.35)
  Top 0.254: C5.2 5.53,26.13 4.52,26.13 4.43,26.04 C3.2 3.81,26.07 v3.81,27.3 | C2.2 1.9,17.75 v1.9,17.14 | C1.2 12.07,27.98 | U1.3 9.41,17.89 10.12,17.18 C4.2 v11.43,17.14 | v13.02,27.3 12.38,27.94 C1.2 | U2.8 28.92,3.84 v29.53,3.84 | U1.19 10.91,26.82 11.38,27.29 11.41,27.29 11.57,27.45 11.57,27.48 C1.2
  Top 0.305: 13.02,13.66 13.02,13.65 | PWR.C 5.4,34.7 | 5.4,34.7 5.62,34.7 | 5.62,34.7 RESET.P$3 10.48,33.45 | 5.62,34.7 5.4,34.7 | RESET.P$4 10.48,33.45 | 10.48,33.45 v10.48,31.75
  Top 0.406: 14.6,14.61 16.51,14.61 17.25,13.87 C6.- 19.21,17.62 19.02,17.82 C7.2 C8.2
  Top 0.508: 13.02,13.65 12.39,13.02 J1.GND 12.39,8.9 v12.38,8.89 | U3.2 14.6,14.61 14.29,14.29 13.65,14.29 13.02,13.66 | v12.38,8.89 v12.38,7.94 v11.43,7.94 v11.43,8.89 v12.38,8.89
  Bottom 0.254: v1.9,17.14 1.9,17.78 | v29.53,3.84 29.53,4.13
  pour Bottom: -3.18,-3.81 -3.18,41.27 109.22,41.27 109.22,0 105.41,-3.81
I2C_SCL
  Top 0.254: U4.P$19 25.18,18.41 25.72,17.87 25.72,16.83 26.35,16.19 29.84,16.19 30.16,16.51 30.16,17.78 30.8,18.41 35.24,18.41 35.88,18.41 37.01,18.41 38.23,19.63 39.24,19.63 40.46,18.41 U5.P$19 55.74,18.41 56.96,19.63 57.97,19.63 59.19,18.41 U6.P$19 74.48,18.41 75.69,19.63 76.71,19.63 77.86,18.48 77.92,18.41 U7.P$19
  Top 0.305: R6.1 35.88,16.53 35.88,18.41
I2C_SDA  (via drill 0.35)
  Top 0.254: U6.P$20 74.48,20.95 75.69,22.17 76.71,22.17 77.92,20.95 U7.P$20 | v32.7,20.95 U4.P$20
  Top 0.305: R7.1 36.38,21.45 35.24,20.32 33.34,20.32 v32.7,20.95
  Bottom 0.254: v32.7,20.95 37.01,20.95 38.23,22.17 39.24,22.17 40.46,20.95 U5.P$20 55.74,20.95 56.96,22.17 57.97,22.17 59.19,20.95 U6.P$20
MISO
  Top 0.254: U4.P$10 37.47,9.53 36.19,9.53 35.56,10.16 35.56,13.34 34.29,14.61 22.62,14.61 21.98,15.24 21.98,18.77 17.28,23.48 U1.15
MOSI
  Top 0.254: U2.3 32.07,10.79 32.7,10.16 34.93,10.16 36.19,8.89 36.19,6.35 36.83,5.71 U4.P$11
MOSI_IN  (via drill 0.35)
  Top 0.254: v26.99,17.46 26.99,18.1 25.4,19.68 21.91,19.68 17.62,23.98 U1.16 | v26.99,12.06 U2.2
  Bottom 0.254: v26.99,17.46 v26.99,12.06
N$1
  Top 0.305: U5.P$1 56.83,30.48 D1.C
N$2
  Top 0.305: R3.1 R6.2
N$3
  Top 0.305: U6.P$1 75.57,30.48 D2.C
N$4
  Top 0.305: U7.P$1 94.3,30.48 D3.C
N$5
  Top 0.254: R1.2 9.93,13.88 9.89,13.84 J1.D+
N$6
  Top 0.305: R4.1 R7.2
N$8
  Top 0.254: R2.2 8.03,13.88 7.89,13.74 J1.D-
N$9
  Top 0.254: Q1.1 5.13,20.38 5.4,20.64 5.4,23.81 5.56,23.98 U1.25
  Top 0.406: C2.1 4.33,18.96 Q1.1
N$10
  Top 0.254: C3.1 3.03,25.58 3.03,25.55 3.2,25.39 4.35,25.39 4.69,25.73 4.7,25.72 U1.24
  Top 0.406: Q1.3 2.03,25.48 C3.1
N$13
  Top 0.254: U7.P$23 78.42,29.84 74.61,29.84 73.34,28.57 U6.P$23 59.69,29.84 59.37,29.84 54.93,29.84 53.66,28.57 U5.P$23 40.96,29.84 35.82,29.84 35.41,30.25 24.36,30.25 U4.P$24
N$14
  Top 0.406: R5.1 PWR.A
N$138
  Top 0.508: F1.1 4.33,12.57 J1.VBUS
RESET  (via drill 0.35)
  Top 0.254: v35.56,26.04 34.29,24.77 29.53,24.77 20.95,24.77 | U7.P$3 81.42,26.04 80.2,27.25 79.19,27.25 77.97,26.04 U6.P$3 62.68,26.04 61.47,27.25 60.45,27.25 59.24,26.04 U5.P$3 43.95,26.04 42.73,27.25 41.72,27.25 40.5,26.04 U4.P$3
  Top 0.305: RESET.P$1 RESET.P$2 19.36,24.77 20.95,24.77
  Bottom 0.254: v35.56,26.04 U4.P$3
SCK  (via drill 0.35)
  Top 0.254: U2.7 v31.43,5.71
  Bottom 0.254: v31.43,5.71 36.51,10.79 U4.P$9
SCK_IN
  Top 0.254: U2.6 21.59,6.99 20.95,7.62 20.95,18.41 16.9,22.48 U1.13
USB_RESET
  Top 0.254: U2.9 32.67,3.2 | 32.67,3.2 32.65,3.17 | U4.P$13 32.65,3.17 | 32.65,3.17 32.67,3.2
USB_RESET_IN
  Top 0.254: U2.10 33.02,5.71 31.75,4.45 29.61,4.45 29.03,5.02 27.6,5.02 27.02,4.45 21.27,4.45 20.64,5.08 20.64,7.36 20.55,7.45 20.55,17.79 16.37,21.98 U1.12
USB_SS
  Top 0.254: U2.5 32.07,8.26 32.7,8.89 35.24,8.89 35.56,8.57 35.56,3.81 36.19,3.17 U4.P$12
USB_SS_IN
  Top 0.254: U2.4 22.22,9.53 21.59,10.16 21.59,15.06 21.58,15.07 21.58,18.43 17.03,22.98 U1.14
VBCOMP
  Top 0.254: C1.1 10.72,27.94 9.41,26.63 U1.22

### Text on the board
tPlace: RESET | Ryzee119 | USB THIS SIDE | USB THIS SIDE | USB THIS SIDE | USB THIS SIDE | ogx360 | PLAYER 1 AND / USB HOST DRIVER | PLAYER 2 | PLAYER 3 | PLAYER 4
bPlace: ogx360 / By Ryzee119 | https://github.com/Ryzee119/ogx360